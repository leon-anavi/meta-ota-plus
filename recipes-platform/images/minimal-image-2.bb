include minimal-image-1.bb

DESCRIPTION = "Minimal OTA-Plus image - with man"


IMAGE_INSTALL_append = " man "
